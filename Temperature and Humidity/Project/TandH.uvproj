# Keil uVision project TandH.uvproj, settings and files
target FLASH (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: TandH +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FWLib;..\User;..\System\MyTime;..\Hardware\LED;..\Hardware\SGM;..\Hardware\DHT11
  group FWLIB
    ../FWLib/: delay.c GPIO.c timer.c
  group SYSTEM
    ../System/MyTime/: MyTime.c
  group USER
    ../User/: main.c
  group HARDWARE
    ../Hardware/LED/: led.c
    ../Hardware/SGM/: sgm.c
    ../Hardware/DHT11/: DHT11.c
